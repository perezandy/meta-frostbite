BUILD_CFLAGS:remove = "-std=gnu99"
BUILD_CFLAGS:append = " -std=gnu11"
